# Keil uVision project CMSIS_GPIO.uvprojx, settings and files
target STM32F103-USB-CDC-CMSIS (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103-USB-CDC-CMSIS
  c flags: Optim=4 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./Src/: main.c
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
